
EXTRA_OECONF_class-target += "--with-selinux=no"
