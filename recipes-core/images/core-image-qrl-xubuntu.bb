DESCRIPTION = "This recipe includes the core packages needed for a qrl system."
AUTHOR = "Gene W. Marsh <gmarsh@codeaurora.org>"

inherit core-image-qrl



IMAGE_FEATURES += "ubuntu userpkgs ubuntuXubuntu"

