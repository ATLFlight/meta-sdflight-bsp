EXTRA_OECONF += "'CPPFLAGS=-I${STAGING_INCDIR}/cairo -I${STAGING_INCDIR}/freetype2 -I${STAGING_INCDIR}/glib-2.0 -I${STAGING_LIBDIR}/glib-2.0/include -I${STAGING_INCDIR}/pango-1.0 -I${STAGING_INCDIR}/gdk-pixbuf-2.0 -I${STAGING_INCDIR}/gio-unix-2.0 -I${STAGING_INCDIR}/atk-1.0'"
