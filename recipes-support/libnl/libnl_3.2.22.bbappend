PKG_${PN}-genl = "libnl-genl-3-200"
