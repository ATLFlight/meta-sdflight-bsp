EXTRA_OECONF += "'CPPFLAGS=-I${STAGING_INCDIR}/freetype2 -I${STAGING_INCDIR}/glib-2.0 -I${STAGING_LIBDIR}/glib-2.0/include'"
