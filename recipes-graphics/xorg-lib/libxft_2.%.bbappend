EXTRA_OECONF += "'CPPFLAGS=-I${STAGING_INCDIR}/freetype2'"
