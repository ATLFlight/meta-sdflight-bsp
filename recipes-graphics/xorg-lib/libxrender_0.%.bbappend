EXTRA_OECONF +="xorg_cv_malloc0_returns_null=yes"
