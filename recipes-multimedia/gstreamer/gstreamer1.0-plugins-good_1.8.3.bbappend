PACKAGECONFIG_remove = "gdk-pixbuf cairo orc"
