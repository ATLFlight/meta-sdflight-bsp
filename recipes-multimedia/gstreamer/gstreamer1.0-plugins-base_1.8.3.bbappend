PACKAGECONFIG_remove = "pango orc"

