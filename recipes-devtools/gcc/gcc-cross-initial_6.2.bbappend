do_spdx[depends] = "gcc-source-6.2.0:do_preconfigure"
