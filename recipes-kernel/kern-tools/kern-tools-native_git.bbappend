SRI_URI += "file://0001-use-only-1-line-for-kver.patch"
