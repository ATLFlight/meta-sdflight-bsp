KERNEL_SRC_PATH = "/usr/src/${MACHINE}"
PROVIDES += "kernel-sdflight-devsrc"
RPROVIDES_${PN} += "kernel-sdflight-devsrc"
